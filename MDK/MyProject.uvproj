# Keil uVision project MyProject.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC16F40K128 Series STC
  cpu: IRAM(0-0x1FFF) XRAM(0x10000-0x17FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: MyProject +hex
  group algorithm
    ../CODES/ALGORITHM/: EM_Calc.c EM_Calc.h EM_FILTER.c EM_FILTER.h LCD_ALGORITHM.c LCD_ALGORITHM.h PID.c PID.h
  group ZF_lib
    ../CODES/Libraries/libraries/: board.c board.h common.c common.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h STC_DFP.LIB STC16Fxx.h
    ../CODES/Libraries/seekfree_libraries/: zf_adc.c zf_adc.h zf_delay.c zf_delay.h zf_exti.c zf_exti.h zf_gpio.c zf_gpio.h zf_iic.c zf_iic.h zf_mdu16.c zf_mdu16.h zf_nvic.c zf_nvic.h zf_pwm.c zf_pwm.h zf_spi.c zf_spi.h zf_tim.c zf_tim.h zf_uart.c zf_uart.h
    ../CODES/Libraries/seekfree_peripheral/: headfile.h SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_ABSOLUTE_ENCODER.c SEEKFREE_ABSOLUTE_ENCODER.h SEEKFREE_AT24C02.c SEEKFREE_AT24C02.h SEEKFREE_BLUETOOTH_CH9141.c SEEKFREE_BLUETOOTH_CH9141.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_IPS114_SPI.c SEEKFREE_IPS114_SPI.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h SEEKFREE_WIRELESS.c SEEKFREE_WIRELESS.h
  group user
    ../CODES/USER/: MyControlSys.h MySteeringControl.h MySteeringPIDAdapter.h MyStepMotorControl.h MyStepMotorPIDAdapter.h isr.h main.c isr.c DEBUG.c
  group driver
    ../CODES/Driver/: EM_SENSOR.c EM_SENSOR.h ENCODE_SENSOR.c ENCODE_SENSOR.h SERVO_MOTOR.c SERVO_MOTOR.h STEP_MOTOR.c STEP_MOTOR.h
